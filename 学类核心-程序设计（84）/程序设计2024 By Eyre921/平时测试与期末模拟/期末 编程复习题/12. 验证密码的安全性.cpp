#include <bits/stdc++.h>
using namespace std;

int plevel(string s)
{
    // 用来标记密码中是否出现了大写字母、小写字母、数字和特殊字符
    bool A = false, a = false, num = false, sp = false;
    int zl = 0;
    size_t len = s.size();
    
    // 用一个哈希表记录每个字符出现的次数，检查是否有重复字符
    unordered_map<char, int> times;

    // 遍历密码字符串
    for (auto c : s)
    {
        // 如果是数字
        if ('0' <= c && c <= '9')
        {
            num = true;
        }
        // 如果是小写字母
        else if ('a' <= c && c <= 'z')
        {
            a = true;
        }
        // 如果是大写字母
        else if ('A' <= c && c <= 'Z')
        {
            A = true;
        }
        // 如果是特殊字符 '_@'
        else if (c == '_' || c == '@')
        {
            sp = true;
        }
        // 如果是其他字符，直接返回0
        else
        {
            return 0;
        }
        
        // 检查是否有重复字符
        times[c]++;
        if (times[c] > 1) return 0;
    }

    // 统计不同字符类型的数量
    if (A) zl++;
    if (a) zl++;
    if (sp) zl++;
    if (num) zl++;

    // 根据长度和字符类型数来判断密码的强度
    if (len >= 12 && zl == 4) return 3;   // 高强度
    if (len >= 8 && len < 12 && zl == 3) return 2;  // 中强度
    if (len >= 6 && len < 8 && zl == 2) return 1;   // 低强度
    return 0;  // 不合格密码
}

int main()
{
    int n;
    cin >> n;  // 读取密码的数量
    for (int i = 0; i < n; i++)
    {
        string s;
        cin >> s;
        cout << plevel(s) << endl;
    }
}
/*
【问题描述】编写一个程序，验证密码的安全性并输出对应的强度等级。密码的合法字符集包含四类字符，即26个大写英文字母、26个小写英文字母、10个数字字符和两种指定的特殊字符（'_'和'@'）。

密码的强度分类如下：

高强度密码：长度大于等于12个字符，且仅同时包含合法字符集中的四类字符，且无重复字符。对应等级为3。

中强度密码：长度大于等于8个小于12个字符，且仅同时包含合法字符集中的任意三类字符，且无重复字符。对应等级为2。

低强度密码：长度大于等于6个小于8个字符，且仅同时包含合法字符集中的任意两类字符，且无重复字符。对应等级为1。

不合格密码：不严格符合以上强度等级，包括但不限于如长度小于6个字符，如只包含其中一种字符，如包含其他字符，如出现重复字符等。对应等级为0。

【输入形式】包括n+1行，第一行输入整数n（1≤n≤10），接下来输入n个密码串，每个密码串至少包含1个字符，且不超过30个字符。

【输出形式】包括n行，每行一个整数，表示对应的密码等级强度值。

【样例输入】

4
Computer@HN_24
nov2035
1234
PWD@123456
【样例输出】

3
1
0
2
【样例说明】

第一个密码串：同时包含四类合法字符，长度等于14，无重复字符，所以判定为高强度密码，输出3。

第二个密码串：仅包含两类合法字符，长度等于7，无重复字符，所以判定为低强度密码，输出1。

第三个密码串：长度等于4，只包含一类字符，所以判定为不合格密码，输出0。

第四个密码串：长度等于10，仅包含三类合法字符，无重复字符出现，所以判定为中强度密码，输出2。

【提示】请严格参照题面描述判定输入的密码串对应的安全等级，题面样例未包含所有的判定条件。保证高中低三种强度的测试用例严格遵循题面规则。
*/
