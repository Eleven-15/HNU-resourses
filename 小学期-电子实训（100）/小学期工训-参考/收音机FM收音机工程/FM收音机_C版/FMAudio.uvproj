# Keil uVision project FMAudio.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: FMAudio +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c FM.c key.c led.c main.c Delay.h FM.h KEY.H led.h reg51.H
